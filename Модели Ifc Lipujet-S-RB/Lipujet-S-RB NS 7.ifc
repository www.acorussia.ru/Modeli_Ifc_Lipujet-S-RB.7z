Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T10:43:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 10:43:32 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{82BEB7EE-FB7F-46A0-8F3B-E78461DD4111}\ifc * Database version: 5507 * Database creation date: Tue May 23 10:43:31 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 10:43:31 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 10:43:31 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Lipurex_ACO:std:14206
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Lipurex; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 2.3
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 1843.5 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
General - RSen_C_intended_use: Entwässerungssysteme
Identity Data - Mark: 9; RSen_C_code_article: 7602.00.25; RSen_C_code_gtin: 04002626143303; RSen_C_description: ACO Fülleinheit für Lipurex-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; option: 1; Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: std, ZZZ_do not use_ME_ST_lipurex_r_options_ACO:std:14196
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, Stainless Steel, Brushed
Type - Identity Data - Manufacturer: Aco; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_lipurex_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: Aco
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Moves With Nearby Elements: no; Offset: 0 mm; right: yes; sight_glass: no
Dimensions - acces_exit_X_pos: 475 mm; access_entry_diameter: 504 mm; access_entry_X_position: 400 mm; Area: 13.1554 m2; bottom_diam: 209 mm; bottom_length: 395 mm; bottom_offset: 8.5 mm; cover_Z_position: 1766.5 mm; D: 160 mm; D1: 1500 mm; disposalpump_angle: 30 deg; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 23.5 mm; disposalpump_OD: 114.3 mm; disposalpump_X: 920 mm; disposalpump_Z: 135.5 mm; DN: 150 mm; footing_radius: 805 mm; glass_Z_position: 1290.5 mm; glasstube_diam: 336 mm; glasstube_length: 1538 mm; H: 1728.5 mm; H1: 1430 mm; H2: 1330 mm; H3: 1780 mm; H4: 2100 mm; inlet_length: 900 mm; L1: 1800 mm; L2: 120 mm; L3: 150 mm; leg_offset: 105 deg; legnumber: 4; logo_Z: 821 mm; outlet_length: 900 mm; rib_diameter: 1548 mm; rib_number: 2; rib_thickness: 35 mm; rib1_Z: 661 mm; rib2_Z: 1046 mm; vent_DN: 100 mm; vent_OD: 110 mm; vent_X: 105 mm; vent_Y: 1000 mm; Volume: 2.84407 m3; waterinlet_angle: -20 deg; waterinlet_OD: 76.1 mm; waterinlet_X: 845 mm; waterinlet_Z: 1568.5 mm
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm
Identity Data - Mark: 8
Model Properties - glass_position: 90 deg; glass_X_position: 769 mm; grease_measure_end_angle: 265 deg; grease_measure_start_angle: 270 deg; grease_measure_X: 50 mm; grease_measure_Y: 1200 mm; grease_measure_Z: 1728.5 mm; heatrod_position: 90 deg; heatrod_Z_position: 976.5 mm
Other - blend_position: 403.5 mm; bottom_plate: no; Family: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; filling_device_option: 1; grease_measure_option: 1; heatrod_option: 1; L2_half: 60 mm; logo_position: 90 deg; lookup_table_name: lipurex_r_basic; options_lookup_table_name: lipurex_r_options; R: 80 mm; R1: 750 mm; sight_glass_option: 1; Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; type_index: 7; Type Id: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; vent_length: 50 mm; waterinlet_end_angle: 25 deg; waterinlet_height: 275 mm; waterinlet_start_angle: 20 deg
Phasing - Phase Created: New Construction
